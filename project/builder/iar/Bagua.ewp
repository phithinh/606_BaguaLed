# IAR project Bagua.ewp, settings and files
configuration Bagua Configuration (ARM, debug)
  General.OGChipSelectEditMenu: STM32F100x6 ST STM32F100x6
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F100xB
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\scrs\_Cube_gen\Inc; ..\..\..\scrs\_Cube_gen\Drivers\STM32F1xx_HAL_Driver\Inc; ..\..\..\scrs\_Cube_gen\Drivers\STM32F1xx_HAL_Driver\Inc\Legacy; ..\..\..\scrs\_Cube_gen\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM3; ..\..\..\scrs\_Cube_gen\Middlewares\Third_Party\FreeRTOS\Source\include; ..\..\..\scrs\_Cube_gen\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ..\..\..\scrs\_Cube_gen\Drivers\CMSIS\Include; ..\..\..\scrs\_Cube_gen\Drivers\CMSIS\Device\ST\STM32F1xx\Include; ..\..\..\project\includes
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\scrs\_Cube_gen\Inc
  OBJCOPY.OOCOutputFile: Bagua.srec
  ILINK.IlinkOutputFile: Bagua Configuration.out
  ILINK.IlinkIcfFile: stm32f100xb_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group _gen/Drivers/CMSIS
    ../../../scrs/_Cube_gen/Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group _gen/Drivers/STM32F1xx_HAL_Driver
    ../../../scrs/_Cube_gen/Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c
  group _gen/EWARM
    ../../../scrs/_Cube_gen/Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/iar/: startup_stm32f100xb.s
  group _gen/Middlewares/FreeRTOS
    ../../../scrs/_Cube_gen/Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../../../scrs/_Cube_gen/Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../scrs/_Cube_gen/Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../scrs/_Cube_gen/Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM3/: port.c portasm.s
  group _gen/User
    ../../../scrs/_Cube_gen/Src/: freertos.c main.c stm32f1xx_hal_msp.c stm32f1xx_it.c
  group Common
    ../../../scrs/bsw/Common/: general_define.h norm.h PlatformDefine.h
  group HardwareAbtract/gpio
    ../../../scrs/bsw/McuDrv/gpio/: gpio.c gpio.h gpio_hardware_config.h
  group rte/scheduler
    ../../../scrs/rte/environment/: environment.c environment.h
  group Software_component/bagua_led
    ../../../scrs/swc/bagua_led/: bagua.c bagua.h
  group Software_component/bagua_led/button_scan
    ../../../scrs/swc/bagua_led/button_scan/: button_scan.c button_scan.h button_scan_adpt.h button_scan_cfg.h button_scan_state.c
